# Keil uVision project SwiftMoteEC_Demo.uvprojx, settings and files
target Release (6180000::V6.18::ARMCLANG)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SwiftMoteEC_Demo +hex
  AfterMake: fromelf.exe --bin Release\Objects\SwiftMoteEC_Demo.axf --output Release\Objects\SwiftMoteEC_Demo.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER STEVAL_IDB011V1 CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_XTAL BLE_STACK_BASIC_CONF
  c misc: -fno-short-wchar
  c include: ..\..\Inc;..\..\Inc\Inc_ad5941;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Middlewares\ST\PKAMGR\Inc;..\..\..\..\..\Middlewares\ST\RNGMGR\Inc;..\..\..\..\..\Middlewares\ST\AESMGR\Inc;..\..\..\..\..\Middlewares\ST\BLECNTR\Inc;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\BSP\Inc;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\Inc;..\..\..\..\..\Middlewares\ST\cryptolib\Inc\Common;..\..\..\..\..\Middlewares\ST\cryptolib\Inc\AES
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group SwiftMoteECDemo_Server
    ../../Src/: gatt_db.c rf_device_it.c sensor.c SensorDemo_main.c rf_device_hal_msp.c
  group AD5941
    ../../Src/AD5941_SqrWaveVoltammetry/: ad5941.c BlueNRG-lpPort.c AD5941Main.c SqrWaveVoltammetry.c
  group Drivers/BSP
    ../../../../../Drivers/BSP/Src/: bluenrg_lp_mote_led.c bluenrg_lp_mote_io.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_lpuart.c rf_driver_ll_pka_v7b.c rf_driver_ll_pwr.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_rtc.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_usart.c rf_driver_ll_utils.c rf_driver_hal.c rf_driver_hal_gpio.c rf_driver_hal_rcc.c rf_driver_hal_rtc.c rf_driver_hal_spi.c rf_driver_hal_dma.c rf_driver_hal_exti.c rf_driver_hal_cortex.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c startup_BlueNRG_LP.c
  group Middlewares/AES
    ../../../../../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/BLECNTR
    ../../../../../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s clock.c context_switch.s gp_timer.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    ../../../../../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lp.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/RNG
    ../../../../../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
